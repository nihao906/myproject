# Keil uVision project 数码管test.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 数码管test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\CORE;.\HARDWARE;.\STM32F10x_FWLib;.\SYSTEM;.\USER;.\STM32F10x_FWLib\src;.\STM32F10x_FWLib\inc;.\USER;..\数码管;.\HARDWARE\OLED
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c init.c init.h
  group SYSTEM
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/delay/: delay.c delay.h
    ./SYSTEM/: Time.c Time.h oled_font.c oled_font.h
    ./: motor.c motor.h MPU6050.c MPU6050.h uart.c uart.h MPU6050_Reg.h Kalman.c Kalman.h pid.c pid.h SPI-OpenMv.c SPI-OpenMv.h
  group HARDWARE
    ./HARDWARE/OLED/: bmp.h oled.c oled.h oledfont.h
    ./HARDWARE/: jy61p.c jy61p.h usart2.c usart2.h
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWlib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
