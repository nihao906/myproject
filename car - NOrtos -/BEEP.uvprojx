# Keil uVision project BEEP.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BEEP +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\RTE;.\RTE\Device\STM32F407ZE;.\HARDWARE;.\HARDWARE;.\SYSTEM;.\CAR;.\FreertosSource\include;.\FreertosSource\portable\RVDS\ARM_CM4F;.\FreertosSource\portable\MemMang
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c
  group HARDWARE
    ./HARDWARE/: EXTI.c EXTI.h ADC.c ADC.h DHT11.c DHT11.h USART2.c USART2.h
  group SYSTEM
    ./SYSTEM/: DELAY.c DELAY.h BITBAND.h
  group CAR
    ./CAR/: motor.c motor.h jy61p.c jy61p.h FTOC.c USART1.c FTOC.h USART1.h PWMB.c PWMA.c PWMB.h PWMA.h pid.c pid.h ENCODERLEFT.c ENCODERLEFT.h ENCODERRIGHT.h ENCODERRIGHT.c USART3.c USART3.h TIMER.c TIMER.h
    ./HARDWARE/: bmp.h oled.c oled.h oledfont.h
  group FREERTOSCORE
    ./FreertosSource/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FREERTOSPORTABLE
    ./FreertosSource/portable/MemMang/: heap_4.c
    ./FreertosSource/portable/RVDS/ARM_CM4F/: port.c portmacro.h
software components: CMSIS:CORE 5.2.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:DAC 1.3.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Flash 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:IWDG 1.3.0, Device:StdPeriph Drivers:PWR 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:RTC 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0, Device:StdPeriph Drivers:WWDG 1.3.0
